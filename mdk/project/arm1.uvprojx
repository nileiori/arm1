# Keil uVision project arm1.uvprojx, settings and files
target INS8001M(ARM1) (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F450II GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arm1 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450,__TARGET_FPU_VFP,ARM_MATH_CM4
  c include: ..\..\GD32F4xx_Firmware_Library\Firmware\CMSIS;..\..\GD32F4xx_Firmware_Library\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\GD32F4xx_Firmware_Library\Firmware\GD32F4xx_standard_peripheral\Include;..\..\mdk;..\..\FreeRTOS;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\src\drivers;..\..\src\api;..\..\src\app;..\..\src\Common\inc;..\..\src\fpga;..\..\src\fpu_lib;..\..\src\algorithm;..\..\src\api\ymodem;..\..\src\littlefs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../: main.c gd32f4xx_it.c systick.c
    ../../src/app/: frame_analysis.c gnss.c computerFrameParse.c Debug.c nav_task.c
  group cmsis
    ../../GD32F4xx_Firmware_Library/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group startup
    ../../GD32F4xx_Firmware_Library/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group peripherals
    ../../GD32F4xx_Firmware_Library/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_can.c gd32f4xx_dbg.c gd32f4xx_dma.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_rtc.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c
  group rtt
    ../../SEGGER_RTT_V766a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Drivers
    ../../src/drivers/: drv_gpio.c drv_spi.c drv_usart.c drv_can.c drv_rtc.c drv_timer.c
  group api
    ../../src/api/: exmc_sram.c serial.c m_queue.c clock.c taskschedule.c fmc_operation.c public.c fwdog.c
    ../../src/api/ymodem/: ymodem.c
  group fpga
    ../../src/fpga/: DRamAdapter.c UartAdapter.c FmcAdapter.c
  group common
    ../../src/Common/src/: Time_Unify.c data_convert.c
  group fpu_lib
    ../../src/fpu_lib/: arm_cortexM4lf_math.lib
  group algorithm
    ../../src/algorithm/: Inavgnss.c Inavins.c inavlog.c Matrix.c
  group freeRTOS
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group littlefs
    ../../src/littlefs/: lfs.c lfs_util.c
software components: Compiler:I/O:STDERR 1.2.0
